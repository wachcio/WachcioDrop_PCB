File: wyświetlacz.kicad_sch (KiCad schematic)
At the start: 19 parts, among them J6 Conn_02x20_Top_Bottom

Commit message: Almoust done
Parts:
- renumbered J6 to J7, R16 to R15, R17 to R16
